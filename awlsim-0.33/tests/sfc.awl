ORGANIZATION_BLOCK OB 1
BEGIN
	// Test SFC -1: __NOP
	CALL		SFC -1


	CALL SFC 46 // STOP CPU
END_ORGANIZATION_BLOCK
